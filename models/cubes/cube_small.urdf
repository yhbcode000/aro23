Commit message: fix cube position

File: models/cubes/cube_small.urdf (robot description, URDF)
Before this commit: robot cube.urdf, 3 links, 2 joints
Links:
- link cubebase: geometry collision mesh filename=cube.obj scale=.1 .1 .1; visual mesh filename=cube.obj scale=.1 .1 .1
